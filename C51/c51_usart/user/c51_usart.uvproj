# Keil uVision project c51_usart.uvproj, settings and files
target c51_usart (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: c51_usart +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Peripherals\inc\
  group user
    ./: main.c
  group Peripherals
    ../Peripherals/src/: stc_it.c usart.c
