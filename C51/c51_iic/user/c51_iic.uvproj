# Keil uVision project c51_iic.uvproj, settings and files
target c51_iic (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: c51_iic +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\PERIPHERALS\INC\
  group Peripherals
    ../Peripherals/src/: usart.c stc_it.c iic.c
  group user
    ./: main.c
